# Keil uVision project template.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER USE_USB_OTG_FS USE_HOST_MODE USE_EMBEDDED_PHY VBUS_SENSING_ENABLED
  c include: .\cmsis;.\spl\inc;.\user;.\usbconfig;.\host\Class\CDC\inc;.\host\Class\HID\inc;.\host\Class\MSC\inc;.\host\Core\inc;.\otg\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/src/: stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c misc.c
  group user
    ./user/: main.c stm32f4xx_it.c usart.c print.c
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group otg
    ./otg/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group host
    ./host/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./host/Class/HID/src/: usbh_hid_core.c usbh_hid_mouse.c usbh_hid_keybd.c
  group usbconfig
    ./usbconfig/: usb_bsp.c usbh_usr.c
