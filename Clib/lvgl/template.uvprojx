# Keil uVision project template.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=111 --diag_suppress=174
  c include: .\cmsis;.\spl\inc;.\user;.\lvgl\lv_core;.\lvgl\lv_draw;.\lvgl\lv_font;.\lvgl\lv_hal;.\lvgl\lv_misc;.\lvgl\lv_objx;.\lvgl\lv_themes;.\lvgl;.\lcd;.\Systick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/src/: stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_fsmc.c
  group user
    ./user/: main.c stm32f4xx_it.c usart.c print.c sram.c
    ./lcd/: FSMClcd.c fonts.c
    ./Systick/: SysTick.c
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group lvgl
    ./lvgl/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ./lvgl/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ./lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./lvgl/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ./lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ./lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group conf
    ./lvgl/: lv_port_disp.c lv_port_fs.c
