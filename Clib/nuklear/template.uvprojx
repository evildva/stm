# Keil uVision project template.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=2816 --diag_suppress=177
  c include: .\cmsis;.\spl\inc;.\user;.\nuklear
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/src/: stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_dma.c
  group user
    ./user/: main.c stm32f4xx_it.c usart.c fonts.c FSMClcd.c
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group nuklear
    ./nuklear/: nuklear_buffer.c nuklear_button.c nuklear_chart.c nuklear_color.c nuklear_color_picker.c nuklear_combo.c nuklear_context.c nuklear_contextual.c nuklear_draw.c nuklear_edit.c nuklear_font.c nuklear_group.c nuklear_image.c nuklear_input.c nuklear_layout.c nuklear_list_view.c nuklear_math.c nuklear_menu.c nuklear_page_element.c nuklear_panel.c nuklear_pool.c nuklear_popup.c nuklear_progress.c nuklear_property.c nuklear_scrollbar.c nuklear_selectable.c nuklear_slider.c nuklear_string.c nuklear_style.c nuklear_table.c nuklear_text.c nuklear_text_editor.c nuklear_toggle.c nuklear_tooltip.c nuklear_tree.c nuklear_utf8.c nuklear_util.c nuklear_vertex.c nuklear_widget.c nuklear_window.c
