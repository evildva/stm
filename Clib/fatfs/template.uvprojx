# Keil uVision project template.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\spl\inc;.\user;.\fatfs;.\STM32_USB_Device_Library\Core\Inc;.\STM32_USB_Device_Library\Class\Template\Inc;.\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/src/: stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c
  group user
    ./user/: main.c stm32f4xx_it.c usart.c
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group fatfs
    ./fatfs/: xprintf.c diskio.c ff.c ffsystem.c ffunicode.c
  group usbcore
    ./STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group usbdev
    ./STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group usbconf
    ./STM32_USB_Device_Library/Core/Src/: usbd_conf_template.c usbd_desc_template.c
    ./STM32_USB_Device_Library/Class/Template/Src/: usbd_template.c
    ./STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_storage_template.c
