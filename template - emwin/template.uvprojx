# Keil uVision project template.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\spl\inc;.\user;.\emwin\Config;.\emwin\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x100000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group user
    ./user/: main.c stm32f4xx_it.c usart.c fonts.c FSMClcd.c
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group conf
    ./emwin/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIDRV_Template.c
  group lib
    ./emwin/Lib/: STemWin532_CM4_Keil.lib
  group os
    ./emwin/OS/: GUI_X.c
