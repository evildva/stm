# Keil uVision project template.uvprojx, settings and files
target pro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: temp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\spl\inc;.\user;.\serial;.\touch;.\ucos\os_conf;.\ucos\uC-CPU;.\ucos\uC-LIB;.\ucos\uCOS_BSP;.\ucos\uCOS-III\Source;.\ucos\uC-CPU\ARM-Cortex-M4\RealView;.\ucos\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\ucos\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group spl
    ./spl/src/: misc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group user
    ./user/: main.c stm32f4xx_it.c usart.c fonts.c FSMClcd.c
  group cmsis
    ./cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group conf
    ./ucos/os_conf/: os_app_hooks.c
  group cpu
    ./ucos/uC-CPU/: cpu_core.c
    ./ucos/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group lib
    ./ucos/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./ucos/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group bsp
    ./ucos/uCOS_BSP/: bsp.c
  group core
    ./ucos/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./ucos/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group touch
    ./touch/: gt5xx.c palette.c touch.c
